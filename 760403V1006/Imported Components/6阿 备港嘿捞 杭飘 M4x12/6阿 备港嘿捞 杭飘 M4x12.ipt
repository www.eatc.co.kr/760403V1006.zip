# Autodesk Inventor part: 6각 구멍붙이 볼트 M4x12
Saved by Autodesk Inventor 2014 (Build 180170000, 170)
## iProperties
Created: 2026-04
Part Number: 6각 구멍붙이 볼트 M4x12
Material: 일반
Document SubType Name: Modeling
Designer: dg
Density: 1 g/cm^3
Appearance: 기본값
Author: dg
Author: jhkim
Description: 6각머리 태핑 나사
Creation Date: 2026-04-06
Sending System: Autodesk Inventor 2027
Preprocessor: ST-DEVELOPER v20.1
## Design history (mm, degrees)
node "6각 구멍붙이 볼트 M4x121"
body "Solid1"
node "기준1"
